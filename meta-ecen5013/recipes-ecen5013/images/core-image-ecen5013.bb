IMAGE_INSTALL_append = "ecen5013-hello-world"
inherit core-image
